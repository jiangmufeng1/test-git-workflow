<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32_modbus_sw2812.ewp</path>
  </project>
  <batchBuild />
</workspace>
